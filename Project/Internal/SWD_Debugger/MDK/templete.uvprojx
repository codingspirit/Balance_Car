# Keil uVision project templete.uvprojx, settings and files
target mk64f12 (5060020::V5.06 (build 20)::ARMCC)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./mk64f12/flash/templete.bin
  c flags: Optim=1
  c define: MK64F12 RAVEN LIB_DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\znfat;..\..\..\..\Libraries\emWin\Include;..\..\..\..\Libraries\emWin\Sample\LCD_X
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup_MK22F25612
    ../../../../Libraries/startup/DeviceSupport/: system_MK22F25612.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK22F25612.s
  group startup_MK20D5
    ../../../../Libraries/startup/DeviceSupport/: system_MK20D5.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK20D5.s
  group user
    ../src/: main.c sw_config.h swd.c flash_kientis.c tflash_mkl46.c
  group drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c systick.c common.c
  group usb
    ../src/USBStack/src/: usbd_core.c usbd_core_msc.c usbd_msc.c
    ../src/USBStack/port/: usbd_kk.c
  group startup_MK64F12
    ../../../../Libraries/startup/DeviceSupport/: system_MK64F12.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK64F12.s
target MK22F25612 (ARM-ADS)
  device: MK22FN256xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) IRAM2(0x1FFFC000,0x4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./mk64f12/flash/templete.bin
  c flags: Optim=1
  c define: MK22F25612  RAVEN DEBUG MKP256
  c misc: --c99 --gnu
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\src\USBStack\inc;..\src\Flash\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
target MK20D5 (ARM-ADS)
  device: MK20DN128xxx5 Freescale
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x2000) IRAM2(0x1FFFE000,0x2000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output ./mk64f12/flash/templete.bin
  c flags: Optim=1
  c define: MK20D5
  c misc: --c99 --gnu
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
